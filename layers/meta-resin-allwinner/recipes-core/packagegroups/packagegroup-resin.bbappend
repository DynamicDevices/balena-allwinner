RDEPENDS_${PN}_nanopi-neo-air += "brcm-patchram-plus \
    nanopi-air-bt \
"
